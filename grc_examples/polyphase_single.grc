options:
  parameters:
    author: matthias
    generate_options: no_gui
    id: polyphase
    max_nouts: '200000'
    output_language: python
    realtime_scheduling: '1'
    title: multi_fm_transmit
  states: {}

blocks:
- name: aud_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: mod_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: num_banks
  id: variable
  parameters:
    value: '30'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass_2(8, num_banks*mod_rate, 120e3, 50e3, 80, window.WIN_BLACKMAN_HARRIS)
  states: {}
- name: taps_rs
  id: variable
  parameters:
    value: firdes.low_pass_2(25.0, 25.0, 0.1, 0.1, 60, window.WIN_KAISER, 7.0)
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: mod_rate
    fh: 10e3
    max_dev: 75e3
    quad_rate: mod_rate
    tau: '75e-6'
  states: {}
- name: analog_wfm_tx_0_0
  id: analog_wfm_tx
  parameters:
    audio_rate: mod_rate
    fh: 10e3
    max_dev: 75e3
    quad_rate: mod_rate
    tau: '75e-6'
  states: {}
- name: analog_wfm_tx_0_0_0
  id: analog_wfm_tx
  parameters:
    audio_rate: mod_rate
    fh: 10e3
    max_dev: 75e3
    quad_rate: mod_rate
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: plughw:UMC1820
    num_outputs: '3'
    ok_to_block: 'False'
    samp_rate: aud_rate
  states: {}
- name: osmosdr_sink_1
  id: osmosdr_sink
  parameters:
    args: '"buffers=1"'
    bb_gain0: '0'
    freq0: '96000000'
    gain0: '0'
    if_gain0: '0'
    sample_rate: mod_rate*num_banks
    sync: none
    type: fc32
  states: {}
- name: pfb_synthesizer_ccf_0
  id: pfb_synthesizer_ccf
  parameters:
    bus_conns: '[[1,],]'
    ch_map: '[1,9,8]'
    connections: '3'
    numchans: num_banks
    taps: taps
    twox: 'False'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    fbw: '0.3'
    interp: '25'
    taps: taps_rs
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    fbw: '0.3'
    interp: '25'
    taps: taps_rs
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    fbw: '0.3'
    interp: '25'
    taps: taps_rs
    type: fff
  states: {}

connections:
- [analog_wfm_tx_0, '0', pfb_synthesizer_ccf_0, '0']
- [analog_wfm_tx_0_0, '0', pfb_synthesizer_ccf_0, '1']
- [analog_wfm_tx_0_0_0, '0', pfb_synthesizer_ccf_0, '2']
- [audio_source_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '1', rational_resampler_xxx_0_0, '0']
- [audio_source_0, '2', rational_resampler_xxx_0_0_0, '0']
- [pfb_synthesizer_ccf_0, '0', osmosdr_sink_1, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_wfm_tx_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', analog_wfm_tx_0_0_0, '0']

metadata:
  file_format: 1
